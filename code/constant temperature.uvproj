# Keil uVision project constant temperature.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: constant temperature +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\st7567
  group Source Group 1
    ./: main.c 18b20.h
  group st7567
    ./st7567/: ASC5X7.h ASC8X16.h CH16X16.h delay.c delay.h picture.h ST7567.c ST7567.h
